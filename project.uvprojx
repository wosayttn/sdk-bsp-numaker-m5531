# Keil uVision project project.uvprojx, settings and files
target rtthread-m5531 (6220000::V6.22::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\components\drivers\include;libraries\m5531\StdDriver\src\scu;libraries\m5531\StdDriver\inc;applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\legacy;libraries\m5531\StdDriver\inc\gdma;rt-thread\libcpu\arm\common;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\dfs\include;libraries\nu_packages\TPC;rt-thread\components\libc\posix\io\stdio;rt-thread\libcpu\arm\cortex-m55;libraries\nu_packages\NuUtils\inc;rt-thread\components\utilities\ulog;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\posix\delay;rt-thread\components\drivers\include;libraries\nu_packages\CMSIS\Core\Include;libraries\m5531\StdDriver\src\gdma;libraries\m5531\rtt_port;board\NuPinConfig;libraries\m5531\Device\Nuvoton\M5531\Include;.;libraries\m5531\StdDriver\inc\scu;rt-thread\components\finsh;board;rt-thread\components\drivers\hwcrypto;rt-thread\components\drivers\include;libraries\m5531\StdDriver;rt-thread\components\fal\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\legacy\dfs;libraries\m5531\StdDriver\src;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\linking_scripts\M5531.scatter
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m55/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    rt-thread/components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    libraries/m5531/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
    libraries/m5531/rtt_port/: cache_ops.c drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_dmic.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gdma.c drv_gpio.c drv_i2c.c drv_i2s.c drv_lpadc.c drv_lpi2c.c drv_lpspi.c drv_lptimer.c drv_lpuart.c drv_memheap.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_sys.c drv_timer.c drv_tpwm.c drv_trng.c drv_ttmr.c drv_uart.c drv_ui2c.c drv_uspi.c drv_uuart.c drv_wdt.c safe_memfun.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_rtt.c fal_partition.c fal_flash.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/m5531/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
    libraries/m5531/StdDriver/src/: nu_acmp.c nu_awf.c nu_bpwm.c nu_canfd.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dmic.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_i3c.c nu_kdf.c nu_ks.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_otfc.c nu_pdma.c nu_pmc.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_spim_hyper.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
    libraries/m5531/StdDriver/src/scu/: nu_dpm.c nu_fvc.c nu_mpc_sie_drv.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
